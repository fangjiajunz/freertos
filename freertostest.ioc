# file: freertostest.ioc
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FREERTOS.Tasks01=defaultTask,0,128,StartDefaultTask,Default,NULL,Dynamic,NULL,NULL
Mcu.Family=STM32F1
Mcu.Name=STM32F103C(8-B)Tx
Mcu.Package=LQFP48
NVIC.PriorityGroup=NVIC_PRIORITYGROUP_4
PA13.Mode=Serial_Wire
PA13.Signal=SYS_JTMS-SWDIO
PA14.Mode=Serial_Wire
PA14.Signal=SYS_JTCK-SWCLK
PC13-TAMPER-RTC.GPIO_ModeDefaultOutputPP=GPIO_MODE_OUTPUT_OD
PC13-TAMPER-RTC.GPIO_PuPd=GPIO_NOPULL
PC13-TAMPER-RTC.Signal=GPIO_Output
PD0-OSC_IN.Mode=HSE-External-Oscillator
PD0-OSC_IN.Signal=RCC_OSC_IN
PD1-OSC_OUT.Mode=HSE-External-Oscillator
PD1-OSC_OUT.Signal=RCC_OSC_OUT
ProjectManager.HeapSize=0x200
ProjectManager.StackSize=0x400
ProjectManager.TargetToolchain=STM32CubeIDE
RCC.AHBFreq_Value=72000000
RCC.APB1CLKDivider=RCC_HCLK_DIV2
RCC.APB1Freq_Value=36000000
RCC.APB1TimFreq_Value=72000000
RCC.APB2Freq_Value=72000000
RCC.APB2TimFreq_Value=72000000
RCC.HCLKFreq_Value=72000000
RCC.PLLMUL=RCC_PLL_MUL9
RCC.PLLSourceVirtual=RCC_PLLSOURCE_HSE
RCC.SYSCLKFreq_VALUE=72000000
RCC.SYSCLKSource=RCC_SYSCLKSOURCE_PLLCLK
RCC.USBFreq_Value=72000000
VP_FREERTOS_VS_CMSIS_V1.Mode=CMSIS_V1
board=custom

// file: Core/Src/main.c
/* USER CODE BEGIN Header */
/**
 ******************************************************************************
 * @file           : main.c
 * @brief          : Main program body
 ******************************************************************************
 * @attention
 *
 * Copyright (c) 2024 STMicroelectronics.
 * All rights reserved.
 *
 * This software is licensed under terms that can be found in the LICENSE file
 * in the root directory of this software component.
 * If no LICENSE file comes with this software, it is provided AS-IS.
 *
 ******************************************************************************
 */
/* USER CODE END Header */
#include "main.h"

#include <stdio.h>

#include "OLED.h"
#include "cmsis_os.h"
#include "gpio.h"

void SystemClock_Config(void);

void MX_FREERTOS_Init(void);

int main(void) {

    /* MCU Configuration--------------------------------------------------------*/

    /* Reset of all peripherals, Initializes the Flash interface and the Systick. */
    HAL_Init();

    /* Configure the system clock */
    SystemClock_Config();

    /* Initialize all configured peripherals */
    MX_GPIO_Init();

    /* Call init function for freertos objects (in cmsis_os2.c) */
    MX_FREERTOS_Init();

    /* Start scheduler */
    osKernelStart();

    /* We should never get here as control is now taken by the scheduler */

    /* Infinite loop */
    while (1) {
    }
}

void SystemClock_Config(void) {
    RCC_OscInitTypeDef RCC_OscInitStruct = {0};
    RCC_ClkInitTypeDef RCC_ClkInitStruct = {0};

    /** Initializes the RCC Oscillators according to the specified parameters
     * in the RCC_OscInitTypeDef structure.
     */
    RCC_OscInitStruct.OscillatorType = RCC_OSCILLATORTYPE_HSI;
    RCC_OscInitStruct.HSIState = RCC_HSI_ON;
    RCC_OscInitStruct.HSICalibrationValue = RCC_HSICALIBRATION_DEFAULT;
    RCC_OscInitStruct.PLL.PLLState = RCC_PLL_NONE;
    if (HAL_RCC_OscConfig(&RCC_OscInitStruct) != HAL_OK) {
        Error_Handler();
    }

    /** Initializes the CPU, AHB and APB buses clocks
     */
    RCC_ClkInitStruct.ClockType = RCC_CLOCKTYPE_HCLK | RCC_CLOCKTYPE_SYSCLK | RCC_CLOCKTYPE_PCLK1 | RCC_CLOCKTYPE_PCLK2;
    RCC_ClkInitStruct.SYSCLKSource = RCC_SYSCLKSOURCE_HSI;
    RCC_ClkInitStruct.AHBCLKDivider = RCC_SYSCLK_DIV1;
    RCC_ClkInitStruct.APB1CLKDivider = RCC_HCLK_DIV1;
    RCC_ClkInitStruct.APB2CLKDivider = RCC_HCLK_DIV1;

    if (HAL_RCC_ClockConfig(&RCC_ClkInitStruct, FLASH_LATENCY_0) != HAL_OK) {
        Error_Handler();
    }
}

void Error_Handler(void) {
    __disable_irq();
    while (1) {
    }
}

// file: Core/Src/freertos.c
/* USER CODE BEGIN Header */
/**
  ******************************************************************************
  * File Name          : freertos.c
  * Description        : Code for freertos applications
  ******************************************************************************
  * @attention
  *
  * Copyright (c) 2024 STMicroelectronics.
  * All rights reserved.
  *
  * This software is licensed under terms that can be found in the LICENSE file
  * in the root directory of this software component.
  * If no LICENSE file comes with this software, it is provided AS-IS.
  *
  ******************************************************************************
  */
/* USER CODE END Header */

#include "FreeRTOS.h"
#include "task.h"
#include "main.h"
#include "cmsis_os.h"

/* USER CODE BEGIN Includes */
#include "OLED.h"
/* USER CODE END Includes */

osThreadId defaultTaskHandle;

/* USER CODE BEGIN FunctionPrototypes */
static SemaphoreHandle_t xOLEDMutex;

void OLED_LockInit() {
    xOLEDMutex = xSemaphoreCreateMutex();
}

void OLED_Lock() {
    xSemaphoreTake(xOLEDMutex, portMAX_DELAY);
}

void OLED_Unlock() {
    xSemaphoreGive(xOLEDMutex);
}

typedef struct {
    uint8_t x;
    uint8_t y;
    char name[16];
} OledMess;

static int g_Oled_Can_Used = 1;
static volatile int g_cal_end = 0;
static uint64_t g_time = 0;
static uint32_t g_sum = 0;

void SumTask(void *pvParameters) {
    uint32_t i = 0;
    TickType_t start_ticks = xTaskGetTickCount();
    for (i = 0; i < 10000000; i++) {
        g_sum += 1;
    }
    g_cal_end = 1;
    TickType_t end_ticks = xTaskGetTickCount();
    g_time = (end_ticks - start_ticks) * portTICK_PERIOD_MS;
    vTaskDelete(NULL);
}

void OledShow(void *params) {
    OLED_ShowString(0, 0, "Waiting..",OLED_8X16);
    OLED_Update();
    while (1) {
        vTaskDelay(3000);
        while (g_cal_end == 0);
        OLED_Clear();
        OLED_ShowString(0, 0, "Sum : ",OLED_8X16);
        OLED_UpdateArea(0, 0, 8, 16);
        if (g_Oled_Can_Used) {
            g_Oled_Can_Used = 0;
            OLED_ShowNum(0, 16, g_sum, 10,OLED_8X16);
            OLED_ShowNum(0, 32, g_time, 10,OLED_8X16);
            OLED_Update();
            g_Oled_Can_Used = 1;
        }
        vTaskDelete(NULL);
    }
}

void oledtest(void *params) {
    OLED_Clear(); // 初始化清屏
    OLED_Update(); // 刷新显示

    while (1) {
        // 显示 "Waiting...."
        OLED_ShowString(0, 0, "Waiting....", OLED_8X16);
        OLED_Update(); // 刷新显示
        vTaskDelay(pdMS_TO_TICKS(2000)); // 延时 2 秒

        // 清除显示的内容
        OLED_ClearArea(0, 0, 127, 16); // 清除区域 (0,0) 到 (127,16)
        OLED_Update(); // 刷新显示
        vTaskDelay(pdMS_TO_TICKS(900)); // 延时 0.9 秒
    }
}

// 定义队列句柄
QueueHandle_t xTestQueue;

// 发送任务
void vQueueSendTask(void *pvParameters) {
    int32_t lValueToSend = 0;
    while (1) {
        lValueToSend++;
        if (xQueueSendToBack(xTestQueue, &lValueToSend, pdMS_TO_TICKS(100)) == pdPASS) {
            OLED_Lock();
            OLED_ShowString(0, 0, "Sent:", OLED_8X16);
            OLED_ShowNum(40, 0, lValueToSend, 4, OLED_8X16);
            OLED_Unlock();
        } else {
            OLED_Lock();
            OLED_ShowString(0, 0, "Queue Full", OLED_8X16);
            OLED_Unlock();
        }
        OLED_Update();
        vTaskDelay(pdMS_TO_TICKS(10)); // 1 秒发送一次
    }
}

// 接收任务
void vQueueReceiveTask(void *pvParameters) {
    int32_t lReceivedValue;
    while (1) {
        if (xQueueReceive(xTestQueue, &lReceivedValue, pdMS_TO_TICKS(500)) == pdPASS) {
            OLED_Lock();
            OLED_ShowString(0, 16, "Recv:", OLED_8X16);
            OLED_ShowNum(40, 16, lReceivedValue, 4, OLED_8X16);
            OLED_Unlock();
        } else {
            OLED_Lock();
            OLED_ShowString(0, 16, "Queue Empty", OLED_8X16);
            OLED_Unlock();
        }
        OLED_Update();
        vTaskDelay(pdMS_TO_TICKS(2000)); // 延时以避免频繁刷新
    }
}

// 初始化队列和任务
void QueueTestInit(void) {
    // 创建队列，容量为 5，每个元素大小为 int32_t
    xTestQueue = xQueueCreate(5, sizeof(int32_t));
    if (xTestQueue == NULL) {
        // 队列创建失败，打印调试信息或其他处理
        OLED_Update();
        OLED_ShowString(0, 0, "Queue Fail", OLED_8X16);
        OLED_Update();
        OLED_Unlock();
        while (1); // 停止运行
    }
    // 创建发送任务
    xTaskCreate(vQueueSendTask, "SendTask", 200, NULL, 2, NULL);
    // 创建接收任务
    xTaskCreate(vQueueReceiveTask, "RecvTask", 200, NULL, 1, NULL);
}

/* USER CODE END FunctionPrototypes */

void StartDefaultTask(void const *argument);

void MX_FREERTOS_Init(void); /* (MISRA C 2004 rule 8.1) */

/* GetIdleTaskMemory prototype (linked to static allocation support) */
void vApplicationGetIdleTaskMemory(StaticTask_t **ppxIdleTaskTCBBuffer, StackType_t **ppxIdleTaskStackBuffer,
                                   uint32_t *pulIdleTaskStackSize);

/* USER CODE BEGIN GET_IDLE_TASK_MEMORY */
static StaticTask_t xIdleTaskTCBBuffer;
static StackType_t xIdleStack[configMINIMAL_STACK_SIZE];

void vApplicationGetIdleTaskMemory(StaticTask_t **ppxIdleTaskTCBBuffer, StackType_t **ppxIdleTaskStackBuffer,
                                   uint32_t *pulIdleTaskStackSize) {
    *ppxIdleTaskTCBBuffer = &xIdleTaskTCBBuffer;
    *ppxIdleTaskStackBuffer = &xIdleStack[0];
    *pulIdleTaskStackSize = configMINIMAL_STACK_SIZE;
    /* place for user code */
}

/* USER CODE END GET_IDLE_TASK_MEMORY */

void MX_FREERTOS_Init(void) {
    /* USER CODE BEGIN Init */
    OLED_Init();
    OLED_LockInit();
    /* USER CODE END Init */

    /* USER CODE BEGIN RTOS_QUEUES */

    //xTaskCreate(oledtest, "oled", 128,NULL, 1,NULL);
    QueueTestInit();
    /* add queues, ... */
    /* USER CODE END RTOS_QUEUES */

    /* Create the thread(s) */
    /* definition and creation of defaultTask */
    osThreadDef(defaultTask, StartDefaultTask, osPriorityNormal, 0, 128);
    defaultTaskHandle = osThreadCreate(osThread(defaultTask), NULL);

}

void StartDefaultTask(void const *argument) {
    for (;;) {
        osDelay(1);
    }
}
